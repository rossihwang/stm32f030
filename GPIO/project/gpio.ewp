# IAR project gpio.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F050x4 ST STM32F050x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX_LD
  ICCARM.CCIncludePath2: ..\user; ..\library\inc; ..\cmsis
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: gpio.out
  ILINK.IlinkIcfFile: ..\iar\stm32f0xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cmsis
    ../cmsis/: stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group lib
    ../library/src/: stm32f0xx_gpio.c stm32f0xx_rcc.c
  group startup
    ../startup/: startup_stm32f0xx.s
  group user
    ../user/: main.c stm32f0xx_conf.h stm32f0xx_it.c
