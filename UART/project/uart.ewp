# IAR project uart.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F050x4 ST STM32F050x4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F0XX_LD
  ICCARM.CCIncludePath2: ..\cmsis; ..\user; ..\library\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: uart.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f050x4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cmsis
    ../cmsis/: stm32f0xx.h system_stm32f0xx.c system_stm32f0xx.h
  group lib
    ../library/src/: stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_usart.c
  group startup
    ../startup/: startup_stm32f0xx.s
  group user
    ../user/: main.c stm32f0xx_conf.h stm32f0xx_it.c
